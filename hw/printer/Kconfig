## hw/printer/Kconfig
```kconfig
config PRINTING
    bool
    default y

config EPSON
    bool
    default y if PRINTING
```
